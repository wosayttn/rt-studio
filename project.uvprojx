# Keil uVision project project.uvprojx, settings and files
target rtthread-m2354 (6130001::V6.13.1::.\ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\nu_packages\NuUtils\inc;packages\lwesp\lwesp\src\include\lwesp\apps;packages\lwesp\lwesp\src\include\cli;packages\lwesp\lwesp\src\include;packages\lwesp\snippets\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;applications;packages\lwesp\lwesp\src\api;rt-thread\libcpu\arm\cortex-m23;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\compilers\common\include;.;packages\lwesp\lwesp\src\cli;board\NuClockConfig;libraries\m2354\StdDriver\inc;applications\lwesp;packages\lwesp\lwesp\src\lwesp;packages\lwesp\lwesp\src\apps\http_server;rt-thread\include;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\lwesp\lwesp\src;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\extension;packages\lwesp\lwesp\src\system;rt-thread\components\drivers\include;packages\lwesp\lwesp\src\include\lwesp;packages\lwesp\lwesp\src\include\system\port;packages\lwesp\lwesp\src\include\system;packages\lwesp\lwesp\src\apps;board;rt-thread\components\drivers\include;libraries\m2354\CMSIS\Include;libraries\m2354\Device\Nuvoton\M2354\Include;libraries\m2354\rtt_port;board\NuPinConfig;packages\lwesp\lwesp;packages\lwesp\lwesp\src\include\system\port\rtthread
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\linking_scripts\m2354_flash.sct
  group Applications
    applications/: main.c lwesp_app.c mnt.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/NuClockConfig/: nutool_modclkcfg.c
    board/: board_dev.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: alarm.c rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    libraries/m2354/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
    libraries/m2354/Device/Nuvoton/M2354/Source/: system_M2354.c
    libraries/m2354/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_can.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_fmc.c drv_gpio.c drv_i2c.c drv_i2s.c drv_otg.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_slcd.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    libraries/m2354/StdDriver/src/: nu_qspi.c nu_usci_uart.c nu_timer_pwm.c nu_qei.c nu_eadc.c nu_sdh.c nu_scuart.c nu_keystore.c nu_ewwdt.c nu_can.c nu_timer.c nu_spi.c nu_gpio.c nu_wwdt.c nu_epwm.c nu_uart.c nu_ewdt.c nu_ecap.c nu_sys.c nu_clk.c nu_crc.c nu_dac.c nu_usci_spi.c nu_pdma.c nu_bpwm.c nu_i2c.c nu_tamper.c nu_sc.c nu_fmc.c nu_lcd.c nu_trng.c nu_usci_i2c.c nu_crypto.c nu_dpm.c nu_rtc.c nu_rng.c nu_i2s.c nu_ebi.c nu_acmp.c nu_wdt.c nu_fvc.c nu_usbd.c
  group lwesp
    packages/lwesp/lwesp/src/api/: lwesp_netconn.c
    packages/lwesp/lwesp/src/apps/http_server/: lwesp_http_server.c lwesp_http_server_fs.c
    packages/lwesp/lwesp/src/cli/: cli.c cli_input.c
    packages/lwesp/lwesp/src/lwesp/: lwesp.c lwesp_ap.c lwesp_buff.c lwesp_cli.c lwesp_conn.c lwesp_debug.c lwesp_dhcp.c lwesp_dns.c lwesp_evt.c lwesp_hostname.c lwesp_input.c lwesp_int.c lwesp_mdns.c lwesp_mem.c lwesp_parser.c lwesp_pbuf.c lwesp_ping.c lwesp_server.c lwesp_smart.c lwesp_sntp.c lwesp_sta.c lwesp_threads.c lwesp_timeout.c lwesp_unicode.c lwesp_utils.c lwesp_webserver.c lwesp_wps.c
    packages/lwesp/lwesp/src/system/: lwesp_ll_rtthread.c lwesp_mem_rtthread.c lwesp_sys_rtthread.c
    packages/lwesp/snippets/: dns.c http_server.c netconn_server.c station_manager.c
